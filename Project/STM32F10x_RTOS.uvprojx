# Keil uVision project STM32F10x_RTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10x_RTOS
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\CMSIS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\ARM_CM3;..\STM32F10x_Libs\inc;..\User;..\Basic\usart;..\Basic\led;..\Basic\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x.h
  group STM32F10x_Libs
    ../STM32F10x_Libs/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Basic
    ../Basic/usart/: usart1.c usart2.c usart3.c
    ../Basic/led/: led.c
    ../Basic/adc/: adc.c
  group User
    ../User/: main.c FreeRTOSConfig.h
